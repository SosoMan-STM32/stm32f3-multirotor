# Keil uVision project stm32f3-multirotor.uvprojx, settings and files
target stm32f3-multirotor (ARM-ADS)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f3-multirotor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Core/Inc;C:/Users/User/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/STM32F3xx_HAL_Driver/Inc;C:/Users/User/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;C:/Users/User/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/CMSIS/Device/ST/STM32F3xx/Include;C:/Users/User/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    C:/Users/User/STM32Cube/Repository/STM32Cube_FW_F3_V1.11.6/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_usb.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.3.0
